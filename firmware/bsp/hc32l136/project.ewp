# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  ICCARM.CCIncludePath2: ..\..\include; Libraries\CMSIS\Include; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common; Libraries\CMSIS\Device\HDSC\HC32L136\Include; drivers; ..\..\components\libc\posix\ipc; Libraries\HC32L136_StdPeriph_Driver\inc; .; applications; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; board; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: __DEBUG; RT_USING_DLIBC; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: stdlib.c time.c
    ../../components/libc/compilers/dlib/: syscall_write.c syscall_remove.c syscalls.c syscall_read.c syscall_lseek.c syscall_mem.c environ.c syscall_close.c syscall_open.c
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: dataqueue.c ringblk_buf.c workqueue.c ringbuffer.c pipe.c waitqueue.c completion.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group HC32_StdPeriph
    Libraries/HC32L136_StdPeriph_Driver/src/: trim.c uart.c sysctrl.c gpio.c ddl.c timer3.c flash.c lpuart.c rtc.c adc.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/: system_hc32l13x.c interrupts_hc32l136.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/IAR/: startup_hc32l136.s
  group Kernel
    ../../src/: components.c irq.c thread.c mempool.c object.c scheduler.c clock.c kservice.c ipc.c timer.c idle.c device.c mem.c
