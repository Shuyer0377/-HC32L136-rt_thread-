# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32L136, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;board;drivers;..\..\components\finsh;Libraries\CMSIS\Include;Libraries\CMSIS\Device\HDSC\HC32L136\Include;Libraries\HC32L136_StdPeriph_Driver\inc;.;..\..\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
    ./applications/: oled.c rtc_calendar.c dht11.c dht11.h
  group Compiler
    ../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c workqueue.c ringbuffer.c pipe.c waitqueue.c ringblk_buf.c dataqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group HC32_StdPeriph
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/ARM/: startup_hc32l136.s
    Libraries/HC32L136_StdPeriph_Driver/src/: trim.c uart.c sysctrl.c gpio.c ddl.c timer3.c flash.c lpuart.c rtc.c adc.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/: system_hc32l13x.c interrupts_hc32l136.c
  group Kernel
    ../../src/: scheduler.c kservice.c device.c clock.c mempool.c components.c timer.c ipc.c irq.c object.c idle.c mem.c thread.c
